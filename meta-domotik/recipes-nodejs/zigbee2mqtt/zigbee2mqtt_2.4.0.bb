SUMMARY = "Zigbee to MQTT bridge using Zigbee-herdsman"
HOMEPAGE = "https://koenkk.github.io/zigbee2mqtt"

LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d \
                    file://node_modules/@babel/runtime/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@colors/colors/LICENSE;md5=12d99be4215ea44df59ce831ed79d258 \
                    file://node_modules/@dabh/diagnostics/LICENSE;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/@isaacs/balanced-match/LICENSE.md;md5=4b364fd4a3785736f483d59601f3bfcf \
                    file://node_modules/@isaacs/brace-expansion/LICENSE;md5=2c7557c15d5e18815804912fd9844b8f \
                    file://node_modules/@isaacs/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
                    file://node_modules/@leichtgewicht/ip-codec/LICENSE;md5=0ab3d176587f714c0377659a2771ac38 \
                    file://node_modules/@serialport/bindings-cpp/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/bindings-cpp/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/@serialport/bindings-interface/LICENSE;md5=e51623d7e3b251d815956df4ea40c6b3 \
                    file://node_modules/@serialport/parser-delimiter/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/parser-readline/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/stream/LICENSE;md5=e2bc0aa64d278eb2b6ddeb692e294945 \
                    file://node_modules/@serialport/stream/node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/@types/node/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/readable-stream/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/triple-beam/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/abort-controller/LICENSE;md5=86a65c5c19c672ee4cd52492495f1d16 \
                    file://node_modules/ajv/LICENSE;md5=5ed8db7ae36f56c8a5cfc218c41ac926 \
                    file://node_modules/ansi-regex/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/ansi-styles/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/argparse/LICENSE;md5=203a6dbc802ee896020a47161e759642 \
                    file://node_modules/async/LICENSE;md5=73f63c1fa4541b2f2f34d77140ebe89d \
                    file://node_modules/base64-js/LICENSE;md5=ea9187ca93cdc4f71219d1675712e908 \
                    file://node_modules/bind-decorator/LICENSE;md5=5015d8872d092147348c347928ab10cb \
                    file://node_modules/bindings/LICENSE.md;md5=471723f32516f18ef36e7ef63580e4a8 \
                    file://node_modules/bl/LICENSE.md;md5=455bc3781a009cf9a615e8622138814c \
                    file://node_modules/bl/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/bl/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/bl/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/bonjour-service/LICENSE;md5=00042654f7b66ce7fb90ac2f5ac22921 \
                    file://node_modules/buffer-crc32/LICENSE;md5=fc1b79f9df9a42722d1bf2ce3ab1b43f \
                    file://node_modules/buffer-from/LICENSE;md5=46513463e8f7d9eb671a243f0083b2c6 \
                    file://node_modules/buffer/LICENSE;md5=e49e579dbcc02cf1f699deec85fd96f0 \
                    file://node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/color-string/LICENSE;md5=330031db3ec2b47f6e9d7923b8e1f95b \
                    file://node_modules/color/LICENSE;md5=2fdebf76c074642a861bf45bf4a8258e \
                    file://node_modules/colorspace/LICENSE.md;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/commist/LICENSE;md5=9d6c3a74d018cc8b3379ce581bcd28ab \
                    file://node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/concat-stream/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/cross-spawn/LICENSE;md5=6046ffd2c9edcd9052bb4dd794d12f95 \
                    file://node_modules/debounce/license;md5=2d6844a6a64c571115c1f30edd019fbf \
                    file://node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/depd/LICENSE;md5=ebc30494fd072dc98368da73e1821715 \
                    file://node_modules/dns-packet/LICENSE;md5=42014010547e55bd3bcac2fec8c45624 \
                    file://node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/enabled/LICENSE;md5=c306c558012a48012189a646e0635014 \
                    file://node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/event-target-shim/LICENSE;md5=893385a31dda2493704bc7f39bc976a0 \
                    file://node_modules/events/LICENSE;md5=d6ec4b5e129a1d757b41126ba3934078 \
                    file://node_modules/express-static-gzip/LICENSE.md;md5=5e58d739be80a061906d39b16a8c17bf \
                    file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/fast-unique-numbers/LICENSE;md5=9c14a4d0f073df3cc102a3e38460f69d \
                    file://node_modules/fast-uri/LICENSE;md5=c67d2a4a86daf7422c31d6d6d63b2bb0 \
                    file://node_modules/fecha/LICENSE;md5=f4f83e94071a71d564921579ec889591 \
                    file://node_modules/file-uri-to-path/LICENSE;md5=9513dc0b97137379cfabc81b60889174 \
                    file://node_modules/finalhandler/LICENSE;md5=462b10b32bb9175b97944aabef4aa171 \
                    file://node_modules/fn.name/LICENSE;md5=d9584417fe22ac64739ce9eb464ef34c \
                    file://node_modules/foreground-child/LICENSE;md5=0069d577f409666fc7a8e879eb49c164 \
                    file://node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/glob/LICENSE;md5=72480347f4e847c91bbe6207b7567338 \
                    file://node_modules/glossy/LICENSE;md5=04598f95a1adcdfb9181e68cbcaea47e \
                    file://node_modules/help-me/LICENSE;md5=f15902492d54d5b2ec098c781019c6dd \
                    file://node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/http-errors/node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/humanize-duration/LICENSE.txt;md5=f4c62131f879a8445e16a7f265aea635 \
                    file://node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/ieee754/LICENSE;md5=56c3be003027d64d24ca6b69a2612f2f \
                    file://node_modules/immediate/LICENSE.txt;md5=364b0dd2a53359063036a25106b75891 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/ip-address/LICENSE;md5=b47884355df53dbe193454cb6a6e6b5b \
                    file://node_modules/is-arrayish/LICENSE;md5=e67c75e89656b80fd99cb7d30fb43102 \
                    file://node_modules/is-fullwidth-code-point/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/is-stream/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/isexe/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/jackspeak/LICENSE.md;md5=9f6dc78e3d8215fcb9da78e5ab9e29af \
                    file://node_modules/js-sdsl/LICENSE;md5=767604b1ed08213fd284407d38e9eec2 \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/jsbn/LICENSE;md5=32052d48bacabd1c02e56c6889082a27 \
                    file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/json-stable-stringify-without-jsonify/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/jszip/LICENSE.markdown;md5=28c4d6943c892a3c61ac2aaa5d781861 \
                    file://node_modules/kuler/LICENSE;md5=07760fd1a905b41fefdc3763afb5dca5 \
                    file://node_modules/lie/license.md;md5=4397773a5104569a0a77b897f979a742 \
                    file://node_modules/logform/LICENSE;md5=69464058e29d977cf9b282e9d8a749e8 \
                    file://node_modules/lru-cache/LICENSE;md5=28b53f8938bb3cf7c37ed8ac5e7d233e \
                    file://node_modules/mime-db/LICENSE;md5=175b28b58359f8b4a969c9ab7c828445 \
                    file://node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/minimatch/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/minipass/LICENSE;md5=5f114ac709a085d123e16c1e6363793f \
                    file://node_modules/mixin-deep/LICENSE;md5=0f64900f8f30e53054962c9f1fc3205b \
                    file://node_modules/moment/LICENSE;md5=397bb5fedab22612d8d69f1458a9321e \
                    file://node_modules/mqtt-packet/LICENSE.md;md5=622e77e45833bb4f785aebc7e41c0bdb \
                    file://node_modules/mqtt/LICENSE.md;md5=261aa46f11e9a7bdbea1dea7eb8bcb6c \
                    file://node_modules/mqtt/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/mqtt/node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/mqtt/node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/multicast-dns/LICENSE;md5=a75272c6b584d0f8e2c1676b4e72469e \
                    file://node_modules/nan/LICENSE.md;md5=3952ff1c51e4ebe5b12c1bc501de4683 \
                    file://node_modules/node-addon-api/LICENSE.md;md5=fc3ff1120869be6b3cce17f9a06bfe2e \
                    file://node_modules/node-gyp-build/LICENSE;md5=bb7eae1c2fbb280c72665db9a1efc896 \
                    file://node_modules/number-allocator/LICENSE;md5=ceff88c0907db57b52716bb46eeaaa2a \
                    file://node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/one-time/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/package-json-from-dist/LICENSE.md;md5=add98d83942d5809bc719262ae40f4ce \
                    file://node_modules/pako/LICENSE;md5=a4f08d6b2d1bf3f3a1bc296a6109a25b \
                    file://node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/path-key/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/path-scurry/LICENSE.md;md5=95e9f67f2840df3a3a09a77ef3aea34b \
                    file://node_modules/path-scurry/node_modules/lru-cache/LICENSE;md5=28b53f8938bb3cf7c37ed8ac5e7d233e \
                    file://node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/process/LICENSE;md5=460a1c62fb575fc77668890ec8d03d0b \
                    file://node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/require-from-string/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/rfdc/LICENSE;md5=fc2ea1f4c58a804909742c8eadede5ea \
                    file://node_modules/rimraf/LICENSE;md5=8b78835ea26f80c9067a0e80a294d926 \
                    file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/safe-stable-stringify/LICENSE;md5=33bb86b5139085dce121f21193b6130c \
                    file://node_modules/safer-buffer/LICENSE;md5=3baebc2a17b8f5bff04882cd0dc0f76e \
                    file://node_modules/semver/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/send/LICENSE;md5=5f1a8369a899b128aaa8a59d60d00b40 \
                    file://node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/setimmediate/LICENSE.txt;md5=af19eaafbc6aa0d2c97538dcfb6db94a \
                    file://node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/shebang-command/license;md5=05240cd20679544d6e90fcff746425bc \
                    file://node_modules/shebang-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/signal-exit/LICENSE.txt;md5=f04dc8bb8ec57c41ddd8ef51491862cb \
                    file://node_modules/simple-swizzle/LICENSE;md5=5db33c6d7c83b57f204826cb21400b88 \
                    file://node_modules/slip/GPL-LICENSE.txt;md5=2c1778696d3ba68569a0352e709ae6b7 \
                    file://node_modules/slip/MIT-LICENSE.txt;md5=b136108764931d4b8b8aacf3ea1af2ff \
                    file://node_modules/smart-buffer/LICENSE;md5=5b37b090a43e81bd880398260c467866 \
                    file://node_modules/socks/LICENSE;md5=742dc14598fb295b01df682683c57709 \
                    file://node_modules/source-map-support/LICENSE.md;md5=f433e270f6b1d088c38b279d53048f5e \
                    file://node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/split2/LICENSE;md5=a3b84061387696c9678867c878a6bbc3 \
                    file://node_modules/sprintf-js/LICENSE;md5=1de2a9f1100beb2ed52da1db9ca232c6 \
                    file://node_modules/stack-trace/License;md5=9fbf93f7a763e64c0a30207b5693bf75 \
                    file://node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/string-width-cjs/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/string-width-cjs/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/string-width-cjs/node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/string-width-cjs/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/string-width/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/strip-ansi-cjs/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/strip-ansi-cjs/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/strip-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/text-hex/LICENSE;md5=d699750183031d92d152d4fb1270b705 \
                    file://node_modules/throttleit/license;md5=a0dcfe5aa5c37ab9c98899d7eb6ea46c \
                    file://node_modules/thunky/LICENSE;md5=0033175ba371b569c73d23fd726c37e8 \
                    file://node_modules/toidentifier/LICENSE;md5=1a261071a044d02eb6f2bb47f51a3502 \
                    file://node_modules/triple-beam/LICENSE;md5=6662ccc5390189c4606fb6b2f726360b \
                    file://node_modules/tslib/CopyrightNotice.txt;md5=cb391e9e435b114c07bee8f6754c4f98 \
                    file://node_modules/tslib/LICENSE.txt;md5=f938d99cba29007eeae26d80a9a4cfa6 \
                    file://node_modules/typedarray/LICENSE;md5=6085b70b74c7dcf7df4e955725e3153d \
                    file://node_modules/undici-types/LICENSE;md5=5809878683f4d0ea6781d9d18e6e6baa \
                    file://node_modules/unix-dgram/LICENSE;md5=1446bae1883758d95cb9a38560963fe9 \
                    file://node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/which/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/winston-syslog/LICENSE;md5=207f20dc9776b79d0aea3637bb06dc03 \
                    file://node_modules/winston-transport/LICENSE;md5=05a0729dc3291972c7b9e521a99a3c1f \
                    file://node_modules/winston-transport/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/winston/LICENSE;md5=124783bb03d1b801c23d11f07b62be0a \
                    file://node_modules/winston/node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/worker-timers-broker/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/worker-timers-worker/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/worker-timers/LICENSE;md5=a2d17a360a8ef9f1d5fbf1c6b77273a3 \
                    file://node_modules/wrap-ansi-cjs/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/wrap-ansi-cjs/node_modules/ansi-regex/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi-cjs/node_modules/ansi-styles/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi-cjs/node_modules/color-convert/LICENSE;md5=9bdadfc9fbb3ab8d5a6d591bdbd52811 \
                    file://node_modules/wrap-ansi-cjs/node_modules/color-name/LICENSE;md5=d301869b39e08b33665b7c4f16b8e41d \
                    file://node_modules/wrap-ansi-cjs/node_modules/emoji-regex/LICENSE-MIT.txt;md5=ee9bd8b835cfcd512dd644540dd96987 \
                    file://node_modules/wrap-ansi-cjs/node_modules/string-width/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi-cjs/node_modules/strip-ansi/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/wrap-ansi/license;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/ws/LICENSE;md5=7a4bd929a6c0e6951846d75e53fc9f51 \
                    file://node_modules/zigbee-herdsman-converters/LICENSE;md5=d1455712aeab4e6c11dbca72e1c0ec27 \
                    file://node_modules/zigbee-herdsman/LICENSE;md5=af7b83a5ff1162a26feb1a736e65b1f5 \
                    file://node_modules/zigbee-herdsman/src/adapter/zigate/driver/LICENSE;md5=932d8c49ab8190efb92cbda10b9c0794 \
                    file://node_modules/zigbee-on-host/LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464 \
                    file://node_modules/zigbee2mqtt-frontend/LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464 \
                    file://node_modules/zigbee2mqtt-windfront/LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464 \
                    file://node_modules/eastasianwidth/README.md;md5=23d7429a66f9cf215a19ab6f62ca93d6 \
                    file://node_modules/isarray/README.md;md5=e7424a48d45a2e04d52c15e786681063 \
                    file://node_modules/object-assign-deep/README.md;md5=57029acacb655ec3d591d698fe251171"

SRC_URI = " \
    npm://registry.npmjs.org/;package=zigbee2mqtt;version=${PV} \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "

S = "${WORKDIR}/npm"

inherit npm

LICENSE:${PN} = "GPL-3.0-only"
LICENSE:${PN}-babel-runtime = "MIT"
LICENSE:${PN}-colors-colors = "MIT"
LICENSE:${PN}-dabh-diagnostics = "MIT"
LICENSE:${PN}-isaacs-balanced-match = "MIT"
LICENSE:${PN}-isaacs-brace-expansion = "MIT"
LICENSE:${PN}-isaacs-cliui = "ISC"
LICENSE:${PN}-leichtgewicht-ip-codec = "MIT"
LICENSE:${PN}-serialport-bindings-cpp = "MIT"
LICENSE:${PN}-serialport-bindings-cpp-debug = "MIT"
LICENSE:${PN}-serialport-bindings-interface = "MIT"
LICENSE:${PN}-serialport-parser-delimiter = "MIT"
LICENSE:${PN}-serialport-parser-readline = "MIT"
LICENSE:${PN}-serialport-stream = "MIT"
LICENSE:${PN}-serialport-stream-debug = "MIT"
LICENSE:${PN}-types-node = "MIT"
LICENSE:${PN}-types-readable-stream = "MIT"
LICENSE:${PN}-types-triple-beam = "MIT"
LICENSE:${PN}-abort-controller = "MIT"
LICENSE:${PN}-ajv = "MIT"
LICENSE:${PN}-ansi-regex = "MIT"
LICENSE:${PN}-ansi-styles = "MIT"
LICENSE:${PN}-argparse = "Python-2.0"
LICENSE:${PN}-async = "MIT"
LICENSE:${PN}-base64-js = "MIT"
LICENSE:${PN}-bind-decorator = "MIT"
LICENSE:${PN}-bindings = "MIT"
LICENSE:${PN}-bl = "MIT"
LICENSE:${PN}-bl-readable-stream = "MIT"
LICENSE:${PN}-bl-safe-buffer = "MIT"
LICENSE:${PN}-bl-stringdecoder = "MIT"
LICENSE:${PN}-bonjour-service = "MIT"
LICENSE:${PN}-buffer = "MIT"
LICENSE:${PN}-buffer-crc32 = "MIT"
LICENSE:${PN}-buffer-from = "MIT"
LICENSE:${PN}-color = "MIT"
LICENSE:${PN}-color-convert = "MIT"
LICENSE:${PN}-color-name = "MIT"
LICENSE:${PN}-color-string = "MIT"
LICENSE:${PN}-colorspace = "MIT"
LICENSE:${PN}-commist = "MIT"
LICENSE:${PN}-concat-stream = "MIT"
LICENSE:${PN}-concat-stream-readable-stream = "MIT"
LICENSE:${PN}-core-util-is = "MIT"
LICENSE:${PN}-cross-spawn = "MIT"
LICENSE:${PN}-debounce = "MIT"
LICENSE:${PN}-debug = "MIT"
LICENSE:${PN}-depd = "MIT"
LICENSE:${PN}-dns-packet = "MIT"
LICENSE:${PN}-eastasianwidth = "MIT"
LICENSE:${PN}-ee-first = "MIT"
LICENSE:${PN}-emoji-regex = "MIT"
LICENSE:${PN}-enabled = "MIT"
LICENSE:${PN}-encodeurl = "MIT"
LICENSE:${PN}-escape-html = "MIT"
LICENSE:${PN}-etag = "MIT"
LICENSE:${PN}-event-target-shim = "MIT"
LICENSE:${PN}-events = "MIT"
LICENSE:${PN}-express-static-gzip = "MIT"
LICENSE:${PN}-fast-deep-equal = "MIT"
LICENSE:${PN}-fast-unique-numbers = "MIT"
LICENSE:${PN}-fast-uri = "BSD-3-Clause"
LICENSE:${PN}-fecha = "MIT"
LICENSE:${PN}-file-uri-to-path = "MIT"
LICENSE:${PN}-finalhandler = "MIT"
LICENSE:${PN}-fnname = "MIT"
LICENSE:${PN}-foreground-child = "ISC"
LICENSE:${PN}-fresh = "MIT"
LICENSE:${PN}-glob = "ISC"
LICENSE:${PN}-glossy = "MIT"
LICENSE:${PN}-help-me = "MIT"
LICENSE:${PN}-http-errors = "MIT"
LICENSE:${PN}-http-errors-statuses = "MIT"
LICENSE:${PN}-humanize-duration = "Unlicense"
LICENSE:${PN}-iconv-lite = "MIT"
LICENSE:${PN}-ieee754 = "BSD-3-Clause"
LICENSE:${PN}-immediate = "MIT"
LICENSE:${PN}-inherits = "ISC"
LICENSE:${PN}-ip-address = "MIT"
LICENSE:${PN}-is-arrayish = "MIT"
LICENSE:${PN}-is-fullwidth-code-point = "MIT"
LICENSE:${PN}-is-stream = "MIT"
LICENSE:${PN}-isarray = "MIT"
LICENSE:${PN}-isexe = "ISC"
LICENSE:${PN}-jackspeak = "BlueOak-1.0.0"
LICENSE:${PN}-js-sdsl = "MIT"
LICENSE:${PN}-js-yaml = "MIT"
LICENSE:${PN}-jsbn = "MIT"
LICENSE:${PN}-json-schema-traverse = "MIT"
LICENSE:${PN}-json-stable-stringify-without-jsonify = "MIT"
LICENSE:${PN}-jszip = "MIT & GPL-3.0-only"
LICENSE:${PN}-kuler = "MIT"
LICENSE:${PN}-lie = "MIT"
LICENSE:${PN}-logform = "MIT"
LICENSE:${PN}-lru-cache = "ISC"
LICENSE:${PN}-mime-db = "MIT"
LICENSE:${PN}-mime-types = "MIT"
LICENSE:${PN}-minimatch = "ISC"
LICENSE:${PN}-minimist = "MIT"
LICENSE:${PN}-minipass = "ISC"
LICENSE:${PN}-mixin-deep = "MIT"
LICENSE:${PN}-moment = "MIT"
LICENSE:${PN}-mqtt = "MIT"
LICENSE:${PN}-mqtt-packet = "MIT"
LICENSE:${PN}-mqtt-readable-stream = "MIT"
LICENSE:${PN}-mqtt-safe-buffer = "MIT"
LICENSE:${PN}-mqtt-stringdecoder = "MIT"
LICENSE:${PN}-ms = "MIT"
LICENSE:${PN}-multicast-dns = "MIT"
LICENSE:${PN}-nan = "MIT"
LICENSE:${PN}-node-addon-api = "MIT"
LICENSE:${PN}-node-gyp-build = "MIT"
LICENSE:${PN}-number-allocator = "MIT"
LICENSE:${PN}-object-assign-deep = "MIT"
LICENSE:${PN}-on-finished = "MIT"
LICENSE:${PN}-one-time = "MIT"
LICENSE:${PN}-package-json-from-dist = "BlueOak-1.0.0"
LICENSE:${PN}-pako = "MIT"
LICENSE:${PN}-parseurl = "MIT"
LICENSE:${PN}-path-key = "MIT"
LICENSE:${PN}-path-scurry = "BlueOak-1.0.0 & ISC"
LICENSE:${PN}-path-scurry-lru-cache = "ISC"
LICENSE:${PN}-process = "MIT"
LICENSE:${PN}-process-nextick-args = "MIT"
LICENSE:${PN}-range-parser = "MIT"
LICENSE:${PN}-readable-stream = "MIT"
LICENSE:${PN}-require-from-string = "MIT"
LICENSE:${PN}-rfdc = "MIT"
LICENSE:${PN}-rimraf = "ISC"
LICENSE:${PN}-safe-buffer = "MIT"
LICENSE:${PN}-safe-stable-stringify = "MIT"
LICENSE:${PN}-safer-buffer = "MIT"
LICENSE:${PN}-semver = "ISC"
LICENSE:${PN}-send = "MIT"
LICENSE:${PN}-serve-static = "MIT"
LICENSE:${PN}-setimmediate = "MIT"
LICENSE:${PN}-setprototypeof = "ISC"
LICENSE:${PN}-shebang-command = "MIT"
LICENSE:${PN}-shebang-regex = "MIT"
LICENSE:${PN}-signal-exit = "ISC"
LICENSE:${PN}-simple-swizzle = "MIT"
LICENSE:${PN}-slip = "MIT & GPL-2.0-only"
LICENSE:${PN}-smart-buffer = "MIT"
LICENSE:${PN}-socks = "MIT"
LICENSE:${PN}-source-map = "BSD-3-Clause"
LICENSE:${PN}-source-map-support = "MIT"
LICENSE:${PN}-split2 = "ISC"
LICENSE:${PN}-sprintf-js = "BSD-3-Clause"
LICENSE:${PN}-stack-trace = "MIT"
LICENSE:${PN}-statuses = "MIT"
LICENSE:${PN}-stringdecoder = "MIT"
LICENSE:${PN}-string-width = "MIT"
LICENSE:${PN}-string-width-cjs = "MIT"
LICENSE:${PN}-string-width-cjs-ansi-regex = "MIT"
LICENSE:${PN}-string-width-cjs-emoji-regex = "MIT"
LICENSE:${PN}-string-width-cjs-strip-ansi = "MIT"
LICENSE:${PN}-strip-ansi = "MIT"
LICENSE:${PN}-strip-ansi-cjs = "MIT"
LICENSE:${PN}-strip-ansi-cjs-ansi-regex = "MIT"
LICENSE:${PN}-text-hex = "MIT"
LICENSE:${PN}-throttleit = "MIT"
LICENSE:${PN}-thunky = "MIT"
LICENSE:${PN}-toidentifier = "MIT"
LICENSE:${PN}-triple-beam = "MIT"
LICENSE:${PN}-tslib = "0BSD"
LICENSE:${PN}-typedarray = "MIT"
LICENSE:${PN}-undici-types = "MIT"
LICENSE:${PN}-unix-dgram = "ISC"
LICENSE:${PN}-util-deprecate = "MIT"
LICENSE:${PN}-which = "ISC"
LICENSE:${PN}-winston = "MIT"
LICENSE:${PN}-winston-syslog = "MIT"
LICENSE:${PN}-winston-transport = "MIT"
LICENSE:${PN}-winston-transport-readable-stream = "MIT"
LICENSE:${PN}-winston-readable-stream = "MIT"
LICENSE:${PN}-worker-timers = "MIT"
LICENSE:${PN}-worker-timers-broker = "MIT"
LICENSE:${PN}-worker-timers-worker = "MIT"
LICENSE:${PN}-wrap-ansi = "MIT"
LICENSE:${PN}-wrap-ansi-cjs = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-ansi-regex = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-ansi-styles = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-color-convert = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-color-name = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-emoji-regex = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-string-width = "MIT"
LICENSE:${PN}-wrap-ansi-cjs-strip-ansi = "MIT"
LICENSE:${PN}-ws = "MIT"
LICENSE:${PN}-zigbee-herdsman = "MIT"
LICENSE:${PN}-zigbee-herdsman-converters = "MIT"
LICENSE:${PN}-zigbee-on-host = "GPL-3.0-or-later"
LICENSE:${PN}-zigbee2mqtt-frontend = "GPL-3.0-only"
LICENSE:${PN}-zigbee2mqtt-windfront = "GPL-3.0-or-later"
