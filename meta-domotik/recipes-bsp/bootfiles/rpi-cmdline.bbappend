CMDLINE:append = " systemd.getty_auto=no"
