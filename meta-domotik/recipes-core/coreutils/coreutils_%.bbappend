# set priority higher (= numerical value below) that of busybox (50)
inherit update-alternatives
ALTERNATIVE_PRIORITY = "40"
