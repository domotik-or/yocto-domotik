require recipes-core/images/core-image-base.bb

DESCRIPTION = "Customized image of core-image-base."
