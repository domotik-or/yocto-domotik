# PACKAGECONFIG:remove = "networkd"
PACKAGECONFIG[networkd] = "-Dnetworkd=false,-Dnetworkd=true"
